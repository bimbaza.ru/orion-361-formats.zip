Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:19:39+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-50023
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Комплекс игровой детский, ZSK-50023 Игровой комплекс «Небесная Башня»
In: Площадка
Description: Комплекс игровой детский. Игровой комплекс «Небесная Башня»; Classification: 59.1.15.01-0532 Комплекс игровой (Классификатор строительных ресурсов (КСР)); Material: Нержавеющая сталь, атмосферостойкий HDPE, армированные канат
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-50023; ModelReference: Игровой комплекс «Небесная Башня»; ProductionYear: 2026; ArticleNumber: ZSK-50023
ORION_Изделие - Артикул: ZSK-50023; Артикул прежний: SD-50023; Наименование: Игровой комплекс «Небесная Башня»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 7.9 x 9.6 м; Зона безопасности: 20.1 x 19.2 м; Высота свободного падения: 1.8 м; Возраст: для детей от 2 до 12 лет; Материал: Нержавеющая сталь, атмосферостойкий HDPE, армированные канаты; Цена: 2 000 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/play-complexes/361; Код КСИ: CPr>EDB080; Класс КСИ: Комплекс игровой; Коды КСР: 59.1.15.01-0532 … 59.1.15.01-0595
ADSK - ADSK_Наименование: Игровой комплекс «Небесная Башня»; ADSK_Марка: ZSK-50023; ADSK_Код изделия: 59.1.15.01-0532; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Нержавеющая сталь, атмосферостойкий HDPE, армированные канаты; ADSK_URL страницы изделия: https://зск.рф/catalog/play-complexes/361
ZSK_Благоустройство - ZSK_Возрастная_группа: для детей от 2 до 12 лет; ZSK_Зона_безопасности: 20.1 x 19.2 м; ZSK_Высота_свободного_падения: 1.8 м; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB080; ZSK_Артикул_прежний: SD-50023
Qto_ORION - Длина: 7900 mm; Ширина: 9600 mm; Высота: 0 mm
